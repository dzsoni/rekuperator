# Keil uVision project rekuperator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: rekuperator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START.A51 readdht11.a51 wdt_t0.a51 delayx.a51 lcd_busy.a51
